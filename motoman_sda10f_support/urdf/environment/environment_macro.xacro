Commit message: Robot poses added

File: motoman_sda10f_support/urdf/environment/environment_macro.xacro (robot description, xacro)
@@ -24,5 +24,5 @@
 			<material name="gray_conveyor"/>
 		</visual>
-</link>
+	</link>
 	<link name="feeder_table">
 		<visual>
